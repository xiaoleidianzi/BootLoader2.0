# Keil uVision project stm32f103.uvprojx, settings and files
target STM32F103 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\core;.\fwlib\inc;.\hardware\inc;.\NET\device\inc;.\NET\protocol\inc;.\user;.\NET\onenet\inc;.\NET\MQTT;.\NET\onenet\inc;.\IAP;.\IAP\sys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group core
    ./core/: core_cm3.c system_stm32f10x.c stm32f10x_it.c
    ./core/startup/arm/: startup_stm32f10x_hd.s
  group fwlib
    ./fwlib/src/: misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_flash.c
  group hardware
    ./hardware/src/: delay.c usart.c beep.c i2c.c sht20.c led.c timer.c
  group user
    ./user/: main.c
  group OneNET
    ./NET/onenet/src/: base64.c hmac_sha1.c onenet.c
  group net_protocol
    ./NET/protocol/src/: onenethttp.c
    ./NET/MQTT/: MqttKit.c
  group net_device
    ./NET/device/src/: esp8266.c
  group IAP
    ./IAP/: iap.c
    ./IAP/sys/: sys.c
